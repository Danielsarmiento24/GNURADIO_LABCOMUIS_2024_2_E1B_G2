options:
  parameters:
    author: Daniel_Sarmiento_Kevin_Tellez
    generate_options: qt_gui
    id: LAB_2A
    output_language: python
    title: parte_1
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: 'Amplitud señal '
    start: '0'
    step: '1e-2'
    stop: '0.5'
    value: '0.5'
  states: {}
- name: 'No'
  id: variable_qtgui_range
  parameters:
    label: 'Amplitud ruido '
    start: '0'
    step: '1e-6'
    stop: '1e-1'
    value: '1e-4'
  states: {}
- name: fcut
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '100'
    stop: '1562500'
    value: '1562500'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: 'Frecuencia de señal '
    start: '1000'
    step: '1000'
    stop: 1e6
    value: '10000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3125000'
  states: {}
- name: t_band
  id: variable_qtgui_range
  parameters:
    label: 'banda de trasmision '
    start: '0'
    step: '100'
    stop: '156250'
    value: '156250'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: 'No'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: A
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: fcut
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: t_band
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_1, '1']
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_add_xx_1, '0', low_pass_filter_0, '0']
- [blocks_throttle2_0, '0', blocks_add_xx_1, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-810-g1ecb8565
